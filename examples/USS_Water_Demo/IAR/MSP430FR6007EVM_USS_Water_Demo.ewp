# IAR project MSP430FR6007EVM_USS_Water_Demo.ewp, settings and files
configuration LPM (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430FR6007 MSP430FR6007
  General.GStackSize2: 512
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __EVM430_ID__=0x47; __EVM430_VER__=0x20; __EXTRA_VERSION__=0x00,0x00; __WATCHDOG_ENABLE__; __SVSH_ENABLE__; __ENABLE_LPM__; xDEBUG_CLOCK_CORRECTION
  ICC430.newCCIncludePaths: ..\..\common\hal\fr6047EVM; ..\..\common\DesignCenter\comm; ..\..\common\DesignCenter\ussDC; ..\..\..\driverlib\MSP430FR5xx_6xx; ..; ..\USSLibGUIApp\fr6007_USS_app; ..\USS_Config; ..\..\..\include; ..\..\common\gui; ..\..\..\lib\USS\source\USS_HAL; ..\..\..\lib\USS\source
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430fr6047.xcl
  XLINK.XlinkStackSize: 1
configuration Disable_LPM (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: __EVM430_ID__=0x47; __EVM430_VER__=0x20; __EXTRA_VERSION__=0x00,0x01; __WATCHDOG_ENABLE__; __SVSH_ENABLE__; xDEBUG_CLOCK_CORRECTION
  group (top)
    ./: lnk430fr6047.xcl
    ../: main.c system_pre_init.c
  group common/DesignCenter/comm
    ../../common/DesignCenter/comm/: comm.c comm.h comm_config.c comm_config.h
  group common/DesignCenter/comm/drivers
    ../../common/DesignCenter/comm/drivers/: i2cslave.c i2cslave.h i2cslave_defs.h timeout.c timeout.h timeout_defs.h uart.c uart.h uart_defs.h
  group common/DesignCenter/comm/protocol
    ../../common/DesignCenter/comm/protocol/: checksum.c checksum.h listener.c listener.h packet.c packet.h
  group common/DesignCenter/comm/utils
    ../../common/DesignCenter/comm/utils/: byte_queue.c byte_queue.h ping_pong_buffer.c ping_pong_buffer.h
  group common/DesignCenter/ussDC
    ../../common/DesignCenter/ussDC/: ussDCCommandHandlers.c ussDCCommandHandlers.h
  group driverlib/MSP430FR5xx_6xx
    ../../../driverlib/MSP430FR5xx_6xx/: adc12_b.c adc12_b.h aes256.c aes256.h comp_e.c comp_e.h crc.c crc.h crc32.c crc32.h cs.c cs.h dma.c dma.h driverlib.h esi.c esi.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h framctl_a.c framctl_a.h gpio.c gpio.h hspll.c hspll.h lcd_c.c lcd_c.h mpu.c mpu.h mpy32.c mpy32.h mtif.c mtif.h pmm.c pmm.h ram.c ram.h ref_a.c ref_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h saph.c saph.h sdhs.c sdhs.h sfr.c sfr.h sysctl.c sysctl.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h uups.c uups.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR5xx_6xx/inc
    ../../../driverlib/MSP430FR5xx_6xx/inc/: hw_memmap.h version.h
  group hal/fr6047EVM
    ../../common/hal/fr6047EVM/: hal.h hal_adc.c hal_adc.h hal_lcd.c hal_lcd.h hal_system.c hal_system.h hal_uart.c hal_uart.h
  group IQMathLib
    ../../../include/: IQmathLib.h
    ../../../lib/IQMathLibrary/libraries/IAR/MPY32/5xx_6xx/: IQmathLib_IAR_MPY32_5xx_6xx_CPUX_large_code_large_data.lib
  group QMathLib
    ../../../include/: QmathLib.h
    ../../../lib/IQMathLibrary/libraries/IAR/MPY32/5xx_6xx/: QmathLib_IAR_MPY32_5xx_6xx_CPUX_large_code_large_data.lib
  group USS_Config
    ../USS_Config/: USS_App_userConfig.c USS_App_userConfig.h USS_intrplCorrLUT.h USS_meterVFRCalib.h USS_userConfig.c USS_userConfig.h
  group USSLibGUIApp/fr6007_USS_app
    ../USSLibGUIApp/fr6007_USS_app/: masterIncludes.h USSLibGUIApp.c USSLibGUIApp.h
  group USSLibGUIApp/fr6007_USS_app/hmiDC
    ../USSLibGUIApp/fr6007_USS_app/hmiDC/: hmi.c hmi.h
  group USSLibGUIApp/fr6007_USS_app/lcd_statemachineDC
    ../USSLibGUIApp/fr6007_USS_app/lcd_statemachineDC/: lcd_statemachine.c lcd_statemachine.h
  group USSLibGUIApp/fr6007_USS_app/mathematicsDC
    ../USSLibGUIApp/fr6007_USS_app/mathematicsDC/: mathematics.c mathematics.h
  group USSLibGUIApp/fr6007_USS_app/resultsDC
    ../USSLibGUIApp/fr6007_USS_app/resultsDC/: results.c results.h
  group USSLibGUIApp/fr6007_USS_app/testingDC
    ../USSLibGUIApp/fr6007_USS_app/testingDC/: testing.c testing.h
  group ussSWLib
    ../../../include/: ussSwLib.h
  group ussSWLib/lib
    ../../../lib/USS_optimized/Lobe/IAR/: USS_SW_IAR_large_code_large_data.lib USS_SW_IAR_large_code_medium_data.lib USS_SW_IAR_large_code_small_data.lib USS_SW_IAR_small_code_large_data.lib USS_SW_IAR_small_code_medium_data.lib USS_SW_IAR_small_code_small_data.lib
  group ussSWLib/source
    ../../../lib/USS/source/: ussSwLibAppDebug.c ussSwLibCalibration.c ussSwLibCalibration.h ussSwLibAlgorithm.c ussSwLibTemperature.c ussSwLibVFRCalib.c ussSwLibVFRCalibFlow.c ussSwLibVFRCalibFlowTemperature.c ussSwLibConfiguration.c ussSwLibISR.c ussSwLibMeasurement.c
  group ussSWLib/source/common
    ../../../lib/USS/source/common/: benchmarkussswLib.c benchmarkussswLib.h USSGenericRegDef.h ussSwLibCommonHSPLL.c ussSwLibCommonHSPLL.h ussSwLibCommonInterrupts.c ussSwLibCommonInterrupts.h ussSwLibCommonSAPH.c ussSwLibCommonSAPH.h ussSwLibCommonSDHS.c ussSwLibCommonSDHS.h ussSwLibCommonTimer.c ussSwLibCommonTimer.h ussSwLibCommonUSS.c ussSwLibCommonUSS.h
  group ussSWLib/USS_HAL
    ../../../lib/USS/source/USS_HAL/: USS_Lib_HAL.c USS_Lib_HAL.h
