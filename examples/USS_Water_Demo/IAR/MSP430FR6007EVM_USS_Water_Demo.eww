<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MSP430FR6007EVM_USS_Water_Demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
